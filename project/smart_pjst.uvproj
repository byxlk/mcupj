# Keil uVision project smart_pjst.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: smart_pjst +hex
  AfterMake: H:\SmartPjsystem\mcupj\tools\DelTempFile_CopyHex.bat
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\code;..\code\stclib
  group Smart_pjst
    ../code/: adxl345.c fzh181.c hx710a.c led_ctrl.c main.c max485.c phase_detect.c relay_ctrl.c sd3178.c api_config.h common.c mem.c
    ../: changelist.txt
  group stclib
    ../code/stclib/: ADC.c EEPROM.c Exti.c GPIO.c PCA.c Soft_UART.c timer.c USART.C spi.c ADC.h EEPROM.h Exti.h GPIO.h PCA.h soft_uart.h spi.h STC15Fxxxx.H timer.h USART.h
