# Keil uVision project pjsy_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: pjsy_test +hex
  AfterMake: H:\SmartPjsystem\mcupj\test\DelTempFile_CopyHex.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: .\code;.\code\stclib
  group pjsy_test
    ./: STARTUP.A51
    ./code/: adxl345.c common.c fzh181.c hx710a.c led_ctrl.c main.c max485.c mem.c phase_detect.c relay_ctrl.c sd3178.c api_config.h
  group stdlib
    ./code/stclib/: ADC.c EEPROM.c Exti.c GPIO.c PCA.c Soft_UART.c spi.c timer.c USART.C
